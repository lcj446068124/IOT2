# Keil uVision project uart.uvprojx, settings and files
target uart (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSP432P401R__
  c include: ..\source\third_party\CMSIS\Include;..\source;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group startup
    ../source/ti/devices/msp432p4xx/startup_system_files/: system_msp432p401r.c
    ../source/ti/devices/msp432p4xx/startup_system_files/keil/: startup_msp432p401r_uvision.s
  group lib
    ../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group user
    ../: main.c myUart.c tick.c buffer.c ATCommand.c cJSON.c sign_mqtt.cpp sign_sha256.cpp exti.c led.c i2c.c oled.c sht2x.c sw.c
